# Keil uVision project vogelscheuche.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: vogelscheuche
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c Timer.c MachineControlPCB_LED.h MachineControlPCB_LED.c MachineControlPCB_Motor.c MachineControlPCB_Motor.h MachineControlPCB_Buttons.c MachineControlPCB_Buttons.h
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:CAN 1.6.0, Device:STM32Cube HAL:CRC 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DAC 1.6.0, Device:STM32Cube HAL:DCMI 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:DMA2D 1.6.0, Device:STM32Cube HAL:ETH 1.6.0, Device:STM32Cube HAL:Flash 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:HCD 1.6.0, Device:STM32Cube HAL:I2C 1.6.0, Device:STM32Cube HAL:I2S 1.6.0, Device:STM32Cube HAL:IRDA 1.6.0, Device:STM32Cube HAL:IWDG 1.6.0, Device:STM32Cube HAL:NAND 1.6.0, Device:STM32Cube HAL:NOR 1.6.0, Device:STM32Cube HAL:PC Card 1.6.0, Device:STM32Cube HAL:PCD 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:RNG 1.6.0, Device:STM32Cube HAL:RTC 1.6.0, Device:STM32Cube HAL:SAI 1.6.0, Device:STM32Cube HAL:SD 1.6.0, Device:STM32Cube HAL:SDRAM 1.6.0, Device:STM32Cube HAL:SPI 1.6.0, Device:STM32Cube HAL:SRAM 1.6.0, Device:STM32Cube HAL:Smartcard 1.6.0, Device:STM32Cube HAL:TIM 1.6.0, Device:STM32Cube HAL:UART 1.6.0, Device:STM32Cube HAL:USART 1.6.0, Device:STM32Cube HAL:WWDG 1.6.0, Device:Startup 2.6.0
